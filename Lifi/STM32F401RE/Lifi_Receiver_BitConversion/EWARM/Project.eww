<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Lifi_Receiver_BitConversion.ewp</path>
  </project>
  <batchBuild />
</workspace>
